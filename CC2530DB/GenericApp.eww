<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GenericApp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>GenericApp</project>
                <configuration>Zintercom_Router</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>Zintercom_Router_PA1</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>Zintercom_Router_PA2</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>Zintercom_EndDevice</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>Zintercom_EndDevice_PA1</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>Zintercom_EndDevice_PA2</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
